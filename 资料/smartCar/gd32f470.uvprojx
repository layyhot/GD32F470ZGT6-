# Keil uVision project gd32f470.uvprojx, settings and files
target GD32F470 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f470 +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470
  c include: .\Fireware\GD32F4xx_standard_peripheral\Include;.\Fireware\CMSIS;.\Fireware\CMSIS\GD\GD32F4xx\Include;.\User;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: gd32f4xx_it.c main.c systick.c sys.c
  group CMSIS
    ./Fireware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./Fireware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Firmware
    ./Fireware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_adc.c
  group Hardware
    ./Hardware/: bsp_buzzer.c bsp_led.c bsp_key.c motor.c motor_pwm.c bsp_usart.c hcsr04.c adc.c track.c
  group Doc
    ./Doc/: readme.txt
